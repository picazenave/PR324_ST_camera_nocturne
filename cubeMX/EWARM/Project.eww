<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PR324_ST_camera_nocturne.ewp</path>
  </project>
  <batchBuild />
</workspace>
